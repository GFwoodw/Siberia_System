## boards/shields/siberia17nrf/Kconfig.defconfig
```kconfig
if SHIELD_SIBERIA17NRF

config ZMK_KEYBOARD_NAME
    default "Siberia17nrf"

endif
```
